# Repository mzuelch/CATs-Eurosynth (continued)

## KiCad design Modules/Slim Line/Slimline Clock Divider/Electronics/Main/Slimline Clock Divider SMD Main.kicad_pcb (continued)

Board: 2 copper layers, 38.1 x 101.6 mm, 42 parts (2 on the bottom side), 32 nets.

## KiCad design Modules/CGS/Analog Switch Matrix/Electronics/Main/CGS Analog Switch Matrix Main.kicad_pcb

Board: 2 copper layers, 38.1 x 101.6 mm, 87 parts (1 on the bottom side), 52 nets.

Parts:
C1, C2, C3, C4, C13, C14, C15, C16, C21, C23: 47p; C_0402_1005Metric
C5, C6, C22: 10µF; CP_EIA-3216-18_Kemet-A
C7, C8, C9, C10, C11, C12, C17, C18, C19, C20, C24: 100n; C_0402_1005Metric
D1, D2: B5817WS; D_SOD-323
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15: 1N4148; D_SOD-323
J1: Power; Power_2x5_Vertical
J2: 1_COM; PinHeader_1x05_P2.54mm_Vertical
J3: 2; PinHeader_1x05_P2.54mm_Vertical
J4: 3; PinHeader_1x05_P2.54mm_Vertical
J5: 4; PinHeader_1x05_P2.54mm_Vertical
J6: POWER; PinHeader_1x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R17, R19, R20, R21, R22, R23, R24, R25, R26, R31, R33, R34: 100k; R_0402_1005Metric
R13, R14, R15, R16, R35: 1k; R_1206_3216Metric
R18: 10k; R_0402_1005Metric
R27, R28, R29, R30: 1k; R_0603_1608Metric
R32: 1k; R_0402_1005Metric
U1, U2, U3, U4, U7: TL072CDT; SOIC-8_3.9x4.9mm_P1.27mm
U5: CD4066BM/TR; SOIC-14_3.9x8.7mm_P1.27mm
U6: TL074IDT; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+12V: C5.1, C7.2, C9.2, C11.2, C17.2, C19.2, C24.2, D1.1, J6.1, R17.2, U1.8, U2.8, U3.8, U4.8, U5.14, U6.4, U7.8
-12V: C6.2, C8.1, C10.1, C12.1, C18.1, C20.1, C22.2, D2.2, J6.5, R32.1, U1.4, U2.4, U3.4, U4.4, U6.11, U7.4
B1: D11.1, R19.2, R27.1, U5.13
B2: D12.1, R20.2, R28.1, U5.5
B3: D13.1, R21.2, R29.1, U5.6
B4: D14.1, R22.2, R30.1, U5.12
C1: J2.4, U6.3
C2: J3.4, U6.12
C3: J4.4, U6.10
C4: J5.4, U6.5
COMOUT: J2.3, R34.1, R35.1
GND: C5.2, C6.1, C7.1, C8.2, C9.1, C10.2, C11.1, C12.2, C17.1, C18.2, C19.1, C20.2, D3.2, D4.2, D5.2, D6.2, D7.2, D8.2, D9.2, D10.2, D15.2, J1.GND, J3.3, J4.3, J5.3, J6.2, J6.3, J6.4, R18.1, U1.3, U1.5, U2.3, U2.5, U3.3, U3.5, U4.3, U4.5, U7.3, U7.5
I1: C1.2, J2.5, R1.2, U1.2
I2: C2.2, J3.5, R2.2, U2.2
I3: C3.2, J4.5, R3.2, U3.2
I4: C4.2, J5.5, R4.2, U4.2
L1: J2.2, R27.2
L2: J3.2, R28.2
L3: J4.2, R29.2
L4: J5.2, R30.2
unnamed: C1.1, R1.1, R5.2, U1.1
unnamed: C2.1, R2.1, R6.2, U2.1
unnamed: C3.1, R3.1, R7.2, U3.1
unnamed: C4.1, R4.1, R8.2, U4.1
unnamed: C13.1, R13.2, U1.7
unnamed: C13.2, D7.1, R9.2, U1.6, U5.2
unnamed: C14.1, R14.2, U2.7
unnamed: C14.2, D8.1, R10.2, U2.6, U5.3
unnamed: C15.1, R15.2, U3.7
unnamed: C15.2, D9.1, R11.2, U3.6, U5.9
unnamed: C16.1, R16.2, U4.7
unnamed: C16.2, D10.1, R12.2, U4.6, U5.10
unnamed: C21.1, R31.1, R33.2, U7.1
unnamed: C21.2, R23.1, R24.1, R25.1, R26.1, R31.2, U7.2
unnamed: C23.1, R35.2, U7.7
unnamed: C23.2, R33.1, R34.2, U7.6
unnamed: D1.2, J1.+12V
unnamed: D2.1, J1.-12V
unnamed: D3.1, R5.1, U5.1
unnamed: D4.1, R6.1, U5.4
unnamed: D5.1, R7.1, U5.8
unnamed: D6.1, R8.1, U5.11
unnamed: D11.2, U6.1
unnamed: D12.2, U6.14
unnamed: D13.2, U6.8
unnamed: D14.2, U6.7
unnamed: R17.1, R18.2, U6.2, U6.6, U6.9, U6.13
O1: J2.1, R9.1, R13.1, R23.2
O2: J3.1, R10.1, R14.1, R24.2
O3: J4.1, R11.1, R15.1, R25.2
O4: J5.1, R12.1, R16.1, R26.2
VEE: C22.1, C24.1, D15.1, R19.1, R20.1, R21.1, R22.1, R32.2, U5.7

## KiCad design Modules/MFOS/Eight Stage Phase Shifter/Electronics/Main/MFOS Eight Stage Phase Shifter - Main.kicad_pcb

File Modules/MFOS/Eight Stage Phase Shifter/README.md:

<h1>MFOS Eight Stage Phase Shifter</h1>
<table>
	<tr valign="top">
		<td></td>
		<td>
			
		</td>
	</tr>
</table>

Board: 2 copper layers, 27.9 x 101.6 mm, 104 parts (1 on the bottom side), 62 nets.

Parts:
C1, C2, C3, C4, C5, C6, C8, C9, C10, C11, C12, C13, C14, C15: 100n; C_0402_1005Metric
C7, C16: 10µF/16V; CP_EIA-3216-18_Kemet-A
C17: 220n; C_0402_1005Metric
C18: 1µF/25V; CP_Elec_4x5.4
C19: 100p; C_0402_1005Metric
C20: 10µF/25V; CP_Elec_5x5.4
C21, C22, C23, C24, C25, C26, C27, C28: 4.7nF; C_0402_1005Metric
C29: 1µF/25V; C_0402_1005Metric
C30, C31: 22pF; C_0402_1005Metric
D1: 1N4148WS; D_SOD-323
D2, D3: 1N5817; D_SOD-323
J1: LFO; PinHeader_1x06_P2.54mm_Vertical
J2: CV_OUT; PinHeader_1x06_P2.54mm_Vertical
J3: In; PinHeader_1x06_P2.54mm_Vertical
J6: Power; Power_2x5_Vertical
Q1, Q3: MMBT3904; SOT-23
Q2: MMBT3906; SOT-23
R2, R5, R9, R14, R19, R33, R36, R39, R41, R55, R58, R60, R61: 10k; R_0402_1005Metric
R3: 43k; R_0402_1005Metric
R7: 270k; R_0402_1005Metric
R8, R31, R34, R37, R40, R51, R52, R53, R54: 1k; R_0402_1005Metric
R11: 430k; R_0402_1005Metric
R12, R17, R20: 100k; R_0402_1005Metric
R13: 1M; R_0402_1005Metric
R22: 2k; R_0402_1005Metric
R23, R25, R27, R29, R32, R35, R38, R42, R43, R45, R47, R49, R56, R57, R59, R62: 30k; R_0402_1005Metric
R24, R26, R28, R30, R44, R46, R48, R50, R64: 20k; R_0402_1005Metric
R65: 33k; R_0402_1005Metric
U1, U2, U3: TL072; SOIC-8_3.9x4.9mm_P1.27mm
U4, U5, U6, U7: LM13700; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+12V: C1.1, C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, C12.1, D2.1, R11.2, R13.2, U1.8, U2.8, U3.8, U4.11, U5.11, U6.11, U7.11
+12V_In: D2.2, J6.+12V
-12V: C5.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, D3.2, R33.1, R36.1, R39.1, R41.1, R55.1, R58.1, R60.1, R61.1, U1.4, U2.4, U3.4, U4.6, U5.6, U6.6, U7.6
-12V_In: D3.1, J6.-12V
CV: J2.1, R11.1, R12.1, R22.2, U3.2
Depth_CW: C17.1, J1.5, R20.1, U2.7
Depth_W: J1.6, R12.2
FB: J3.4, R9.2
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.2, C13.1, C14.1, C15.1, C16.1, C29.2, J2.2, J2.3, J2.4, J3.2, J3.3, J6.GND, Q2.2, Q3.1, R31.1, R34.1, R37.1, R40.1, R51.1, R52.1, R53.1, R54.1, U1.3, U1.5, U2.2, U2.5, U3.3, U3.5, U4.3, U4.14, U5.3, U5.14, U6.3, U6.14, U7.3, U7.14
Iabc: Q2.3, R24.2, R26.2, R28.2, R30.2, R44.2, R46.2, R48.2, R50.2
In: C18.1, J3.1
Mode_In: J1.3, R8.1
Mode_Out: C17.2, J1.4, R17.1, U2.6
unnamed: C18.2, R5.2
unnamed: C19.1, R14.2, U3.7
unnamed: C19.2, Q1.3, R13.1, U3.6
unnamed: C20.1, R19.1, R65.2
unnamed: C21.1, U4.5, U4.7
unnamed: C22.1, U4.10, U4.12
unnamed: C22.2, R25.2, R32.1, R33.2, U4.8
unnamed: C23.1, U5.5, U5.7
unnamed: C23.2, R27.2, R35.1, R36.2, U4.9
unnamed: C24.1, U5.10, U5.12
unnamed: C24.2, R29.2, R38.1, R39.2, U5.8
unnamed: C25.1, U6.5, U6.7
unnamed: C26.1, U6.10, U6.12
unnamed: C26.2, R45.2, R55.2, R56.1, U6.8
unnamed: C27.1, U7.5, U7.7
unnamed: C27.2, R47.2, R57.1, R58.2, U6.9
unnamed: C28.1, U7.10, U7.12
unnamed: C28.2, R49.2, R59.1, R60.2, U7.8
unnamed: C30.2, R5.1, R9.1, R19.2, U1.2
unnamed: C31.2, R2.1, R3.2, U1.6
unnamed: D1.1, R8.2
unnamed: Q1.1, R22.1, U3.1
unnamed: Q1.2, Q3.2, R14.1
unnamed: Q2.1, Q3.3
unnamed: R7.2, R20.2, U2.3
unnamed: R23.1, R31.2, R32.2, U4.4
unnamed: R24.1, U4.1
unnamed: R25.1, R34.2, R35.2, U4.13
unnamed: R26.1, U4.16
unnamed: R27.1, R37.2, R38.2, U5.4
unnamed: R28.1, U5.1
unnamed: R29.1, R40.2, R42.2, U5.13
unnamed: R30.1, U5.16
unnamed: R43.1, R51.2, R56.2, U6.4
unnamed: R44.1, U6.1
unnamed: R45.1, R52.2, R57.2, U6.13
unnamed: R46.1, U6.16
unnamed: R47.1, R53.2, R59.2, U7.4
unnamed: R48.1, U7.1
unnamed: R49.1, R54.2, R62.2, U7.13
unnamed: R50.1, U7.16
unnamed: R64.2, U2.1
OUT4: C25.2, J3.5, R2.2, R41.2, R42.1, R43.2, U5.9
OUT8: J3.6, R61.2, R62.1, U7.9
Out1: C30.1, J2.5, R65.1, U1.1
Out2: C31.1, J2.6, R3.1, U1.7
PSS_In: C20.2, C21.2, R23.2
Rate_CW: C29.1, D1.2, J1.1, R7.1, R64.1
Rate_W: J1.2, R17.2

## KiCad design Modules/CGS/Analog Switch Matrix/Electronics/Control/CGS Analog Switch Matrix Control.kicad_pcb

Board: 2 copper layers, 38.1 x 101.6 mm, 48 parts (5 on the bottom side), 33 nets.

Parts:
C1, C2: 100n; C_Rect_L7.0mm_W2.5mm_P5.00mm
C3, C4: 47p; C_Rect_L7.0mm_W2.5mm_P5.00mm
D1, D2, D3, D4: Green; LED_D3.0mm
J1: Common In; Jack_3.5mm_QingPu_WQP-PJ301M-12
J2: In 1; Jack_3.5mm_QingPu_WQP-PJ301M-12
J3: In 2; Jack_3.5mm_QingPu_WQP-PJ301M-12
J4: In 3; Jack_3.5mm_QingPu_WQP-PJ301M-12
J5: In 4; Jack_3.5mm_QingPu_WQP-PJ301M-12
J6: Control 1; Jack_3.5mm_QingPu_WQP-PJ301M-12
J7: Control 2; Jack_3.5mm_QingPu_WQP-PJ301M-12
J8: Control 3; Jack_3.5mm_QingPu_WQP-PJ301M-12
J9: Control 4; Jack_3.5mm_QingPu_WQP-PJ301M-12
J10: Common Out; Jack_3.5mm_QingPu_WQP-PJ301M-12
J11: Out 1; Jack_3.5mm_QingPu_WQP-PJ301M-12
J12: Out 2; Jack_3.5mm_QingPu_WQP-PJ301M-12
J13: Out 3; Jack_3.5mm_QingPu_WQP-PJ301M-12
J14: Out 4; Jack_3.5mm_QingPu_WQP-PJ301M-12
J15: 1_COM; PinSocket_1x05_P2.54mm_Vertical
J16: 2; PinSocket_1x05_P2.54mm_Vertical
J17: 3; PinSocket_1x05_P2.54mm_Vertical
J18: 4; PinSocket_1x05_P2.54mm_Vertical
J19: POWER; PinSocket_1x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R13, R14, R15, R16, R17, R18, R19, R20: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R9, R10, R11, R12: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U1: TL072; DIP-8_W7.62mm_LongPads

Connections:
+12V: C1.2, J19.1, U1.8
-12V: C2.1, J19.5, U1.4
C1: J15.4, R9.1, R13.1
C2: J16.4, R10.1, R14.1
C3: J17.4, R11.1, R15.1
C4: J18.4, R12.1, R16.1
COMIN: C4.1, R1.2, R3.2, R5.2, R7.2, R20.1, U1.7
COMOUT: J10.T, J15.3
GND: C1.1, C2.2, D1.1, D2.1, D3.1, D4.1, J1.S, J1.TN, J2.S, J2.TN, J3.S, J3.TN, J4.S, J4.TN, J5.S, J5.TN, J6.S, J6.TN, J7.S, J7.TN, J8.S, J8.TN, J9.S, J9.TN, J10.S, J11.S, J12.S, J13.S, J14.S, J16.3, J17.3, J18.3, J19.2, J19.3, J19.4, R13.2, R14.2, R15.2, R16.2, U1.3, U1.5
I1: J15.5, R1.1, R2.1
I2: J16.5, R3.1, R4.1
I3: J17.5, R5.1, R6.1
I4: J18.5, R7.1, R8.1
L1: D1.2, J15.2
L2: D2.2, J16.2
L3: D3.2, J17.2
L4: D4.2, J18.2
unnamed: C3.1, R18.1, R19.2, U1.1
unnamed: C3.2, R17.1, R18.2, U1.2
unnamed: C4.2, R19.1, R20.2, U1.6
unnamed: J1.T, R17.2
unnamed: J2.T, R2.2
unnamed: J3.T, R4.2
unnamed: J4.T, R6.2
unnamed: J5.T, R8.2
unnamed: J6.T, R9.2
unnamed: J7.T, R10.2
unnamed: J8.T, R11.2
unnamed: J9.T, R12.2
O1: J11.T, J15.1
O2: J12.T, J16.1
O3: J13.T, J17.1
O4: J14.T, J18.1

## Commit log

2021-03-16 Update
    Commit
2021-05-01 Update fp-info-cache
2021-06-12 4Ch Mixer added
2021-06-12 S&H added
2021-06-12 Clock Divider added
2021-06-12 Single VCA added
2021-06-12 Update Baby8
2021-06-17 Steiner VCF added
2021-06-18 STEP Updated
2021-07-12 Updat6e Steiner VCF
2021-11-11 Update
    Update
2022-01-24 HAGIWO 6Ch Trigger Sequencer
2022-01-24 Ringfolder
2022-01-24 Arduino VCO
2022-01-24 Abakus
2022-01-25 Test
2022-01-28 Create LICENSE
2022-01-29 Display
2022-01-30 4Ch Sampler
2022-02-01 MFOS Update
2022-02-02 Manual Gate
2022-02-03 First Case Added
2022-02-03 Case Update
2022-02-04 3x3He Case Added
2022-02-04 QR Codes
2022-02-04 typo
2022-02-04 typo again
2022-02-06 HAGIWO Sync LFO
2022-02-06 HAGIWO Sync LFO Update
2022-02-06 W806 Documentation
2022-02-07 CAD Update
2022-02-07 Blind 3TE
2022-02-09 Noise Update
2022-02-09 Bugfix
2022-02-10 Precision Adder added
2022-02-10 Balanced Modulator
2022-02-11 KiCad 6 Update
2022-02-16 Envelope Follower Simulation
2022-02-16 Envelope Follower Update
2022-02-17 HAGIWO Firmware Update
2022-02-17 Update Firmware
2022-02-18 Envelope Follower
2022-02-19 Rectifier
2022-02-19 Major Update
2022-02-19 Update Arduino VCO
2022-02-19 Arduino VCO Update
2022-02-21 Firmware Update 6Ch Sequencer
2022-02-21 bug fix
2022-03-13 HAGIWO SH101
2022-05-15 Slimline VCA
2022-05-15 SlimLine VCA Mechanics
2022-05-17 Vactrol VCF
2022-06-02 HAGIWO Display Panel
    This Panel exposes the copper Layer to the Front and is meant to be fabricated with ENIG plating.
    We had some fun with KiCad and learned a bit while making these.
2022-06-03 Alternative Front fpr HAGIWO Display
2022-06-12 Classic ADSR
2022-06-16 Artwork
2022-09-18 Eight Stage Phase Shifter
2022-09-25 BOMs
2022-09-29 Change encoder direction
2022-10-06 Update ReadMe.md
    New Images and Video link
2022-10-21 Buffered Multiple V2
2022-11-05 Analog Switch Matrix
2022-11-29 Update Display page
    Add DIY Info, Links, Videos and Pictures
2022-11-29 typo
    fix typo
2023-01-02 correct wrong link
2023-02-12 Slimline Clock Divider NG
2023-02-14 Add HAGIWO EG sketch for Sync LFO HW
    This is the code HAGIWO published for his dual AD Envelope generator.
    I wanted to try this on the great Sync LFO hardware Michael made available here.
2023-02-14 Add Bezier curve random CV sketch
    This is the Bezier curve random CV generator code from HAGIWO adapted for the Sync LFO.
    I just love this
2023-03-15 Slimline Voltage Controlled Switch
2023-03-25 Update Sync LFO
2023-03-25 small usability changes
    Make space for a shrouded IDC header. Mark the USB connector direction on the backside.
2023-03-25 readme fix
    Make space for a shrouded IDC header. Mark the USB connector direction on the backside.
2023-03-25 Add files via upload
    Move components for shrouded IDC header. Add Silkscreen for USB Connector
2023-03-26 Update SyncLFO
2023-03-30 Add Generative Sequencer firmware for Hagiwo Sync Mod LFO.
2023-03-30 disable debug by default in repo
2023-04-04 removed Periphery.h
2023-05-06 Add multi-mode envelope generator script.
2023-05-08 Fix formatting and correct curve duty range.
2024-08-25 Update HAGIWO_Display.ino
    Included a Global Menu. (pressing the encoder for 3 seconds)
    This Global Menu would allow you to:
    1# Change the direction of the rotary encoder (mine was backwards)
    2# Change the time the menu will stay on the top from 1 second up to 60 seconds.
    To exit the Menu just leave the encoder pressed for 3 seconds.
    Both menu changes will persist on restart.
2024-08-25 Update HAGIWO_Display.ino
    Reduced jitter
2024-08-25 Update HAGIWO_Display.ino
    Fixed a bug where Encoder EEPROM Address required 2 bytes to store the negative values.
