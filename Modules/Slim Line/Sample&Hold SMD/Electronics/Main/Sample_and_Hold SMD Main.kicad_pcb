# Repository mzuelch/CATs-Eurosynth

File README.md:

<h1>CAT's Eurosynth</h1>
<p>This is my repository for my analog synth eurorack compatible modules. Files given via the "Gerber" directories are actual production data used for my own prototyping. Bugs are to be expected. Corrections for finished boards marked as "working" are done in KiCAD only.</p>
<p>Please read the "Known Issues" section given in this repository as "ReadMe.md" whenever appropriate.</p>
<h1>License</h1>
<p>Code (AVR projects): GPL3.0.</p>
<p>Code (STM32F projects): MIT license.</p>
<p>Hardware: CC BY-NC-SA 4.0</p>

<p>unless specified otherwise.</p>
<h2>Custom Libraries</h2>
<p>Most of the schematics and layouts use custom libraries since some of the stock libries are either buggy or unsuited for my designs. The libraries can be found <a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Libraries">here</a>.</p>
<p>I am about to remodel all the KiCAD Files to use environment variables:</p>
<table>
	<tr>
		<th>Variable</th>
		<th>points to</th>		
	</tr>
	<tr>
		<td>KI_CUSTOM_MOD</td>
		<td>Footprint Data (where all the .pretty stuff is hidden)</td>		
	</tr>
	<tr>
		<td>KI_CUSTOM_3DMOD</td>
		<td>3D Model Data (where all the .3dshapes stuff is hidden)</td>		
	</tr>
	<tr>
		<td>KI_CUSTOM_SYMBOLS</td>
		<td>Symbol Data (where all the .lib stuff is hidden)</td>		
	</tr>
</table>
<p>Layout specific data (mainly front panel stuff) are stored in the corresponding folders. Most of the Links are absolute atm. I will change them as soon as the particular layout is modified.</p>
<p>Proper Aliases and other informations are given in these ReadMe's:</p> 
<ul>
	<li><a href="https://github.com/mzuelch/CATs-Eurosynth/blob/main/Libraries/Symbols/ReadMe.md">Symbols</a></li>
	<li><a href="https://github.com/mzuelch/CATs-Eurosynth/blob/main/Libraries/Footprints/ReadMe.md">Footprints</a></li>
	<li><a href="https://github.com/mzuelch/CATs-Eurosynth/blob/main/Libraries/3D%20Shapes/ReadMe.md">3D Shapes</a></li>
</ul>
<h1>Published Designs</p>
<h2>Standard Line</h2>
<p>Collection of modules with no regard to size. These designs are based on either my own ideas and mistakes or published in so many places I can't figure out the original source.</p>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/Power%20Module">Power Module (THT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/Atari%20Punk%20Console">Atari Punk Console (THT, Working)</a></h3>
<h3><s>Baby8 Sequencer (THT, Rework)</s></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/4Ch%20Mixer">4Ch Mixer (SMT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/Clock%20Divider">Clock Divider (THT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/Abakus">Abakus (SMT/THT, Working)</a></h3>
<h3><s>Manual Gate (THT, Rework)</s></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/Envelope%20Follower">Envelope Follower (THT, WIP)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/Vactrol%20VCF">Vactrol VCF (THT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Standard%20Line/Classic%20ADSR">Classic ADSR (SMT, Working)</a></h3>
<h2>Slim Line</h2>
<p>Slim Modules to cope with the ever increasing lamentations from my bandmates and wife. Also these designs are based on either my own ideas and mistakes or published in so many places I can't figure out the original source.</p>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Attenuator">Single Attenuator (THT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Buffered%20Multiple">Buffered Multiple (THT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Buffered%20Multiple%20SMD">Buffered Multiple SMD (SMT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Sample%26Hold">Dual Sample&Hold (THT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Sample%26Hold%20SMD">Dual Sample&Hold SMD (SMT/THT, WIP)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Precision%20Adder">Precision Adder (SMT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Rectifier%20SMD">Rectifier SMD(SMT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/VCA">VCA (THT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Clock%20Divider">Clock Divider (SMT, Working)</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Slim%20Line/Voltage%20Controlled%20Switch">Voltage Controlled Switch (SMT, Working)</a></h3>

<h2>Purely Mechanical</h2>
<p>Some purely mechanical projects - blinds, cases,...</p>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Mechanicals/Blinds/1TE">1TE Blind Panel</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Mechanicals/Blinds/3TE">3TE Blind Panel</a></h3>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Mechanicals/Cases">Cases</a></h3>

<h2>MFOS Clones</h2>
<p>The basic electronic design was made by <a href="http://musicfromouterspace.com/">Music From Outer Space</a>.
The remodelling in KiCAD, slight adaptation, PCB layout and frontpanel designs are based on my own faults</p>
<p>RIP Ray Wilson</p>
<h3>Dual VCA #2 (THT, Working)</h3>
<ul>
	<li><a href="http://musicfromouterspace.com/analogsynth_new/OLDIESBUTGOODIES/VCA/dualvca-2.html">Original Build Documentation</a></li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/MFOS/Noise%20Cornucopia">Noise Cornucopia (THT, Working)</a></h3>
<ul>
	<li><a href="http://musicfromouterspace.com/analogsynth_new/NOISECORNREV01/NOISECORNREV01.php">Original Build Documentation</a></li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/MFOS/Eight%20Stage%20Phase%20Shifter">Eight Stage Phase Shifter (SMT, Working)</a></h3>
<ul>
	<li><a href="http://musicfromouterspace.com/analogsynth_new/PHASESHIFTER2007/PHASESHIFTER2007.php">Original Build Documentation</a></li>
</ul>

<h2>YuSynth Clones</h2>
<p>The basic electronic design was made by <a href="https://yusynth.net">YuSynth</a>.
The remodelling in KiCAD, slight adaptation (especially changes to +/-12V), PCB layout and frontpanel designs are based on my own faults.</p>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/YuSynth/Improved%20Steiner%20VCF">Improved Steiner VCF (SMT, Working)</a></h3>
<ul>
	<li><a href="http://yusynth.net/Modular/EN/STEINERVCF/index-v2.html">Original Build Documentation</a></li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/YuSynth/Balanced%20Modulator"><b>Single</b> balanced Modulator (THT/SMT, WIP)</a></h3>
<ul>
	<li><a href="http://yusynth.net/Modular/EN/RINGMOD/index.html">Original Build Documentation</a></li>
</ul>

<h2>Haraldswerk</h2>
<p>The basic electronic design was made by <a href="https://www.haraldswerk.de/">Haraldswerk</a>.
The remodelling in KiCAD, slight adaptation (especially to Eurorack format), PCB layout and frontpanel designs are based on my own faults.</p>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/Haraldswerk/NGF-E%20LFO/">Next Generation Formant LFO (THT, Working)</a></h3>
<ul>
	<li><a href="https://www.haraldswerk.de/NGF_E/NGF_E_LFO/NGF_E_LFO.html">Original Build Documentation</a></li>
</ul>

<h2>Ken Stone / Cat Girl Synth</h2>
<p>The basic electronic design was made by <a href="https://sdiy.info/wiki/CatGirl_Synth">Ken Stone aka Cat Girl Synth</a>.
The remodelling in KiCAD, slight adaptation (especially changes to +/-12V), PCB layout and frontpanel designs are based on my own faults</p>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/CGS/Analog%20Switch%20Matrix">Analog Switch Matrix (THT/SMT, Working)</a></h3>
<ul>
	<li><a href="https://sdiy.info/wiki/CGS_analog_switch_matrix">Original Build Documentation</a></li>
</ul>

<h2>HAGIWO</h2>
<p>The basic electronic design was made by <a href="https://www.youtube.com/channel/UCxErrnnVNEAAXPZvQFwobQw">HAGIWO</a>.
The remodelling in KiCAD, slight adaptation in hard- and software, PCB layout and frontpanel designs are based on my own faults.</p>
<p>The schematics are Public Domain, firmware is Open Source unless otherwise specified.</p>
<p>This part of the repository is made public with permission from HAGIWO itself. I really appreciate it.</p>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/HAGIWO/6Ch%20Trigger%20Sequencer">6Ch Trigger Sequencer (SMT, Working)</a></h3>
<ul>
	<li>
		<strong>6Ch Gate Sequencer</strong>
		<br><a href="https://www.youtube.com/watch?v=YszdC8YdFl0&t">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n17c69afd484d">Original Build Documentation</a>
	</li>
	<li>
		<strong>6Ch Euclidian Rythm Sequencer</strong>
		<br><a href="https://www.youtube.com/watch?v=lkoBfiq6KPY">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n433b32ea6dbc">Original Build Documentation</a>
	</lt>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/HAGIWO/Ringfolder">Ringfolder (SMT, Working)</a></h3>
<ul>
	<li>
		<strong>Ring Modulator & Wavefolder</strong>
		<br><a href="https://www.youtube.com/watch?v=gYwEPNSfJLE">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n9d138d74b39d">Original Build Documentation</a>
	</li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/HAGIWO/Multiout">Multiout (SMT, Working)</a></h3>
<ul>
	<li>
		<strong>Sequencer Roland SH-101 type</strong>
		<br><a href="https://www.youtube.com/watch?v=--qb_QYZrTk&t">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n80f4baf81226">Original Build Documentation</a>
	</li>
	<li>
		<strong>Dual quantizer and Envelope generator</strong>
		<br><a href="https://www.youtube.com/watch?v=6FJpljEYZq4">YouTube</a>
		<br><a href="https://note.com/solder_state/n/nb8b9a2f212a2">Original Build Documentation</a>
	</li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/HAGIWO/Display">Display (SMT, Working)</a></h3>
<ul>
	<li>
		<strong>Oscilloscope & Spectrum analyzer</strong>
		<br><a href="https://www.youtube.com/watch?v=yAes5pS3ZTo">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n6b4cc8d1c6b9">Original Build Documentation</a>
	</li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/HAGIWO/Arduino%20VCO">Arduino VCO (SMT, Working)</a></h3>
<ul>
	<li>
		<strong>Additive VCO</strong>
		<br><a href="https://www.youtube.com/watch?v=wjWOJ-h5w5w">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n30b3a8737b1e">Original Build Documentation</a>
	</li>
	<li>
		<strong>Chord VCO</strong>
		<br><a href="https://www.youtube.com/watch?v=Ikhd3OmoN40">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n681d2e07e324">Original Build Documentation</a>
	</li>
	<li>
		<strong>FM VCO</strong>
		<br><a href="https://www.youtube.com/watch?v=NZKacfP9aNI">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n88317851a4c7">Original Build Documentation</a>
	</li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/HAGIWO/4Ch%20Sample%20Player">4Ch Sample Player (SMT, Working)</a></h3>
<ul>
	<li>
		<strong>TR-808/909 sample play , 4CH wav trigger</strong>
		<br><a href="https://www.youtube.com/watch?v=7Vcwk8KYZM8&t">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n0209d16d0d08">Original Build Documentation</a>
	</li>
</ul>
<h3><a href="https://github.com/mzuelch/CATs-Eurosynth/tree/main/Modules/HAGIWO/Sync%20LFO">Sync LFO (SMT, Working)</a></h3>
<ul>
	<li>
		<strong>Clock Sync LFO</strong>
		<br><a href="https://www.youtube.com/watch?v=m64jyVz2w3M">YouTube</a>
		<br><a href="https://note.com/solder_state/n/n4c600f2431c3">Original Build Documentation</a>
	</li>
</ul>

## KiCad design Modules/Slim Line/Sample&Hold SMD/Electronics/Main/Sample_and_Hold SMD Main.kicad_pcb

Parts:
C1, C2: 1nF; C_0402_1005Metric; LCSC C1523
C3, C8, C9, C10, C11, C12, C13, C14: 100nF; C_0402_1005Metric; LCSC C307331
C4, C5: 10µF; CP_EIA-3216-18_Kemet-A; LCSC C7171
C6, C7: 10nF; C_0402_1005Metric; LCSC C15195
D1, D2: 1N4148WS; D_SOD-323; LCSC C2128
D3, D4: 1N5819WS; D_SOD-323; LCSC C191023
J1: Trigger 2; PJ-324M-3
J2: In 2; PJ-324M-3
J3: Trigger 1; PJ-324M-3
J4: In 1; PJ-324M-3
J5: Power; Power_2x8_Horizontal
J6: Out 2; PJ-324M-3
J7: Out 1; PJ-324M-3
R1, R2, R3, R4, R5, R6, R9, R11, R12: 100k; R_0402_1005Metric; LCSC C25741
R8: 1k; R_0402_1005Metric; LCSC C11702
R13, R14: 1k; R_1206_3216Metric; LCSC C4410
U1, U4: OP07CDR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C7433
U2, U3: LF398; DIP-8_W7.62mm_LongPads

Connections:
+12V: C3.1, C4.1, C8.1, C9.1, C10.1, D3.1 (K), R9.1, U1.7 (V+), U2.1 (V+), U3.1 (V+), U4.7 (V+)
-12V: C5.2, C11.2, C12.2, C13.2, C14.2, D4.2 (A), U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-)
GND: C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, J1.S, J2.S, J3.S, J3.TN, J4.S, J4.TN, J5.GND, J6.S, J7.S, R1.1, R2.1, R5.1, R6.1, R8.1, R11.1, R12.1, U2.7 (T), U3.7 (T)
unnamed: C1.1, D1.2 (A), R11.2
unnamed: C1.2, U4.6
unnamed: C2.1, D2.2 (A), R12.2
unnamed: C2.2, U1.6
unnamed: C6.1, U2.6 (Ch)
unnamed: C7.1, U3.6 (Ch)
unnamed: D1.1 (K), U2.8 (Hold)
unnamed: D2.1 (K), U3.8 (Hold)
unnamed: D3.2 (A), J5.+12V
unnamed: D4.1 (K), J5.-12V
unnamed: J1.T, R3.1
unnamed: J1.TN, J3.T, R4.1
unnamed: J2.T, R1.2, U2.3 (I)
unnamed: J2.TN, J4.T, R2.2, U3.3 (I)
unnamed: J6.T, R13.1
unnamed: J7.T, R14.1
unnamed: R3.2, R5.2, U4.3 (+)
unnamed: R4.2, R6.2, U1.3 (+)
unnamed: R13.2, U2.5
unnamed: R14.2, U3.5
Vref: R8.2, R9.2, U1.2 (-), U4.2 (-)

Board: 2 copper layers, 38.1 x 101.6 mm, 41 parts (0 on the bottom side), 24 nets.

File Modules/Slim Line/Sample&Hold SMD/Electronics/Main/production/Sample_and_Hold_SMD_Main_2024-01-10_17-02-40/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0402,2,1nF,
"C10, C11, C12, C13, C14, C3, C8, C9",0402,8,100nF,
"C4, C5",CP_EIA-3216-18_Kemet-A,2,10µF,
"C6, C7",0402,2,10nF,
"D1, D2",D_SOD-323,2,1N4148WS,
"D3, D4",D_SOD-323,2,1N5819WS,
J1,PJ-324M-3,1,Trigger 2,
J2,PJ-324M-3,1,In 2,
J3,PJ-324M-3,1,Trigger 1,
J4,PJ-324M-3,1,In 1,
J5,Power_2x8_Horizontal,1,Power,
J6,PJ-324M-3,1,Out 2,
J7,PJ-324M-3,1,Out 1,
"R1, R11, R12, R2, R3, R4, R5, R6, R9",0402,9,100k,
"R13, R14",1206,2,1k,
R8,0402,1,1k,
"U1, U4",SOIC-8_3.9x4.9mm_P1.27mm,2,OP07CDR,
"U2, U3",DIP-8_W7.62mm_LongPads,2,LF398,

## KiCad design Modules/HAGIWO/Sync LFO/Electronics/Main/HAGIWO Sync LFO Main.kicad_pcb

File Modules/HAGIWO/Sync LFO/ReadMe.md:

<h2>Revision History</h2>
<table>
	<tr>
		<th>Revision</th>
		<th>Changes</th>
	</tr>
	<tr>
		<td>012202</td>
		<td>Initial Release</td>
	</tr>
	<tr>
		<td>022303</td>
		<td>Arduino Nano rotated by 180deg. No changes in pot or jack position. PCB layout adapted accordingly.<br>Make space for a shrouded IDC header. Mark the correct header and USB connector orientation on the backside.</td>
	</tr>
</table>

<h2>Modulove Appendix</h2>
This is a PCB version of the awesome HAGIWO Clock SYNC LFO.
It was published on Github by [mzuelch](https://github.com/mzuelch/ "mzuelch") and we (modulove) put together the design & kits in our lab.

The module is a Arduino-based LFO and can be clocked / synced via the trigger input and offers internal modulation to create complex waveforms.
It can be modified / reprogrammed easily with the Arduino IDE.

It offers six waveforms and the following hardware features:

- Panel Design by [bkrsmdesign](https://www.instagram.com/bkrsmdesign/ "Sasha Kruse")
- Knob1: Amplifier control. Set the output voltage
- Knob2: Phase control. Set the phase from 0-360°
- Knob3: Waveform control. Select the waveform type.
- Knob4: Internal modulation, creating complex waveforms.
- CLK in: Clock IN.
- OUTPUT Voltage 0/+10V
- Skiff friendly & 6P
- 50 mA draw

<h1>Changes mzuelch made to the original design</h1>
<ul>
	<li>PWM -> Analog Conversion by active Steiner LPF (fg=500Hz) instead of passive RC network</li>
	<li>Unipolar output changed from 0/+5V to 0/+10V</li>
	<li>Additional bipolar output +/-10V</li>
	<li>Additional inverted bipolar output +/-10V</li>
</ul>

DIY Info:

Building the Module is simple and suited for beginners. The Kit comes with SMD parts already soldered.

Assembly Instructions / Video [here](https://youtube.com/playlist?list=PL9-2_fDMIm5cuEoAXl6-avylgxBkOdHC9 "HAGIWO module build video")

More Info:

- [HAGIWO original Articles](https://note.com/solder_state/n/n4c600f2431c3 "HAGIWO Sync LFO module article").

- [HAGIWO Display Video](https://www.youtube.com/watch?v=m64jyVz2w3M "HAGIWO Clock Sync LFO module Youtube Video").

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C2, C3, C4: 220p; C_0402_1005Metric; LCSC C1530
C5: 6.8n; C_0402_1005Metric; LCSC C1542
C6: 10n; C_0402_1005Metric; LCSC C15195
C7, C9, C10, C12, C13: 100n; C_0402_1005Metric; LCSC C1525
C8, C11: 10u; CP_EIA-3216-18_Kemet-A; LCSC C7171
D1: BAV99,215; SOT-23; LCSC C2500
D2: LED; LED_D3.0mm
D3, D4: 1N5819; D_SOD-323; LCSC C191023
J1: UP_Out; Jack_3.5mm_QingPu_WQP-PJ301M-12
J2: CLK In; Jack_3.5mm_QingPu_WQP-PJ301M-12
J3: BP_Inv_Out; Jack_3.5mm_QingPu_WQP-PJ301M-12
J4: BP_Out; Jack_3.5mm_QingPu_WQP-PJ301M-12
J5: Power; Power_2x5_Vertical
P1, P3, P4: B100K; Potentiometer_AlpsAlpine_RK09L1140_wo_Fix
P2: B100K; Potentiometer_AlpsAlpine_RK09L1140
R1, R2, R3, R4: 470R; R_0402_1005Metric; LCSC C25117
R5: 13k; R_0603_1608Metric; LCSC C22797
R6: 27k; R_0402_1005Metric; LCSC C25771
R7, R10, R16, R21: 1k; R_0402_1005Metric; LCSC C11702
R8: 300R; R_0402_1005Metric; LCSC C25102
R9, R11, R13, R15, R17, R18, R19, R20: 10k; R_0402_1005Metric; LCSC C25744
R12: 100k; R_0402_1005Metric; LCSC C25741
R14: 20k; R_0402_1005Metric; LCSC C25765
U1, U2: TL072; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C6961

Connections:
+5V: A1.27 (+5V), D1.2 (A), P1.CW, P2.CW, P3.CW, P4.CW, R18.2
+12V: A1.30 (VIN), C8.1, C9.2, C10.2, D3.1 (K), U1.8 (V+), U2.8 (V+)
-5VA: R15.2, R17.1, U1.7
-12V: C11.2, C12.1, C13.1, D4.2 (A), U1.4 (V-), U2.4 (V-)
A0: A1.19 (A0), C2.1, R2.1
A1: A1.20 (A1), C3.1, R3.1
A3: A1.22 (A3), C1.1, R1.1
A5: A1.24 (A5), C4.1, R4.1
D3: A1.6 (D3), D1.3 (K), R10.1, R12.2
D10: A1.13 (D10), R5.2, R8.2
GND: A1.4 (GND), A1.29 (GND), C1.2, C2.2, C3.2, C4.2, C6.1, C7.1, C8.2, C9.1, C10.1, C11.1, C12.2, C13.2, D1.1 (K), D2.1 (K), J1.S, J2.S, J2.TN, J3.S, J4.S, J5.GND, P1.CCW, P2.CCW, P3.CCW, P4.CCW, R11.1, R12.1, U1.5 (+), U2.3 (+), U2.5 (+)
unnamed: C5.2, R5.1, R6.2
unnamed: C6.2, R6.1, U1.3 (+)
unnamed: D2.2 (A), R8.1
unnamed: D3.2 (A), J5.+12V
unnamed: D4.1 (K), J5.-12V
unnamed: J1.T, R7.1
unnamed: J2.T, R10.2
unnamed: J3.T, R16.1
unnamed: J4.T, R21.1
unnamed: P1.W, R1.2
unnamed: P2.W, R2.2
unnamed: P3.W, R3.2
unnamed: P4.W, R4.2
unnamed: R9.2, R11.2, U1.2 (-)
unnamed: R13.1, R14.2, R15.1, U2.2 (-)
unnamed: R14.1, R16.2, R20.2, U2.1
unnamed: R17.2, R18.1, U1.6 (-)
unnamed: R19.1, R21.2, U2.7
unnamed: R19.2, R20.1, U2.6 (-)
Out: C5.1, C7.2, R7.2, R9.1, R13.2, U1.1

Notes on the sheet:
Amp
Waveform
Phase
Mod

Board: 2 copper layers, 29.2 x 101.6 mm, 50 parts (41 on the bottom side), 31 nets.

## KiCad design Modules/Slim Line/Rectifier SMD/Electronics/Main/Rectifier Main.kicad_pcb

Parts:
C1: 22p; C_0402_1005Metric; MPN C1555
C2, C5: 10uF/16V; CP_EIA-3216-18_Kemet-A; MPN C7171
C3, C4, C6, C7: 100n; C_0402_1005Metric; MPN C307331
D1, D2, D3, D4, D5, D6: 1N4148WS; D_SOD-323; MPN C2128
D7, D8: 1N5819WS; D_SOD-323; MPN C1884554
J1: Full Wave; Jack_3.5mm_QingPu_WQP-PJ324M
J2: Negative HW; Jack_3.5mm_QingPu_WQP-PJ324M
J3: In; Jack_3.5mm_QingPu_WQP-PJ324M
J4: Positive HW; Jack_3.5mm_QingPu_WQP-PJ324M
J5: Power; Power_2x8_Horizontal
R1, R2, R4, R5, R6, R8, R9, R10, R11: 100k; R_0603_1608Metric; MPN C335088
R3, R7, R12: 1k; R_1206_3216Metric; MPN C4410
U1: TL082CDT; SOIC-8_3.9x4.9mm_P1.27mm; MPN C13460
U2: TL084CDT; SOIC-14_3.9x8.7mm_P1.27mm; MPN C11130

Connections:
+12V: C2.1, C3.1, C4.2, D7.1 (K), U1.8 (V+), U2.4 (V+)
-12V: C5.2, C6.2, C7.1, D8.2 (A), U1.4 (V-), U2.11 (V-)
GND: C2.2, C3.2, C4.1, C5.1, C6.1, C7.2, J1.S, J2.S, J3.S, J3.TN, J4.S, J5.GND, R4.1, U2.3 (+), U2.5 (+), U2.10 (+)
unnamed: C1.1, D1.2 (A), R1.1, U1.2 (-)
unnamed: C1.2, D1.1 (K), D2.2 (A), U1.1
unnamed: D2.1 (K), R4.2, U1.5 (+)
unnamed: D3.1 (K), D4.2 (A), U2.7
unnamed: D3.2 (A), R5.1, R6.2, U2.6 (-)
unnamed: D4.1 (K), R7.1
unnamed: D5.1 (K), D6.2 (A), U2.1
unnamed: D5.2 (A), R8.1, R11.2, U2.2 (-)
unnamed: D6.1 (K), R12.1
unnamed: D7.2 (A), J5.+12V
unnamed: D8.1 (K), J5.-12V
unnamed: J1.T, R2.2, R3.2
unnamed: J2.T, R5.2, R7.2
unnamed: J3.T, R6.1, R10.1, U1.3 (+)
unnamed: J4.T, R8.2, R12.2
unnamed: R1.2, R2.1, U1.6 (-)
unnamed: R3.1, U1.7
unnamed: R9.1, R10.2, U2.9 (-)

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
Board: 2 copper layers, 38.1 x 101.6 mm, 34 parts (0 on the bottom side), 22 nets.

## KiCad design Modules/Slim Line/Voltage Controlled Switch/Electronics/Main/Slimline Voltage Controlled Switch - Main.kicad_pcb

File Modules/Slim Line/Voltage Controlled Switch/README.md:

<h1>Slimline Voltage Controlled Switch</h1>
<table>
	<tr valign="top">
		<td></td>
		<td>
			<p>
				Slimline Voltage Controlled Switch
			</p>
		</td>
	</tr>
</table>

Board: 2 copper layers, 38.1 x 101.6 mm, 62 parts (0 on the bottom side), 35 nets.

Parts:
C1, C2, C3, C4: 47p; C_0402_1005Metric
C5, C10, C12: 10µF; CP_EIA-3216-18_Kemet-A
C6, C7, C8, C9, C11, C13, C14, C15: 100n; C_0402_1005Metric
D1, D2, D3, D4, D6, D8, D10: 1N4148WS; D_SOD-323
D5, D7: LED; LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm
D9, D11: 1N5817WS; D_SOD-323
J1: IN 1; Jack_3.5mm_QingPu_WQP-PJ324M
J2: OUT 1; Jack_3.5mm_QingPu_WQP-PJ324M
J3: IN 2; Jack_3.5mm_QingPu_WQP-PJ324M
J4: OUT 2; Jack_3.5mm_QingPu_WQP-PJ324M
J5: Switch 1; Jack_3.5mm_QingPu_WQP-PJ324M
J6: Switch 2; Jack_3.5mm_QingPu_WQP-PJ324M
J7: Power; Power_2x8_Horizontal
Q1, Q2: MMBT3904; SOT-23
R1, R2, R3, R4, R6, R7, R8, R9, R12, R14, R15, R16, R21, R22, R23: 100k; R_0402_1005Metric
R5, R10: 1k; R_1206_3216Metric
R11, R18: 1k; R_0603_1608Metric
R13, R17, R20: 10k; R_0402_1005Metric
R24: 1k; R_0402_1005Metric
U1, U3, U4: TL072CDT; SOIC-8_3.9x4.9mm_P1.27mm
U2: CD4066BM/TR; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+12V: C5.1, C6.2, C7.2, C8.2, C11.2, D9.1, R11.1, R12.2, R18.1, U1.8, U2.14, U3.8, U4.8
-12V: C10.2, C12.2, C13.1, C14.1, C15.1, D11.2, R17.1, U1.4, U3.4, U4.4
B1: D6.1, R14.1, R16.2, U2.5
B2: D8.1, R21.1, R23.2, U2.12
GND: C5.2, C6.1, C7.1, C8.1, C9.2, C11.1, C12.1, C13.2, C14.2, C15.2, D1.2, D2.2, D3.2, D4.2, D10.2, J1.S, J1.TN, J2.S, J3.S, J3.TN, J4.S, J5.S, J5.TN, J6.S, J6.TN, J7.GND, Q1.2, Q2.2, R15.1, R22.1, R24.2, U1.3, U1.5, U3.3, U3.5
unnamed: C1.1, R2.1, R4.2, U1.1
unnamed: C1.2, R2.2, R3.1, U1.2
unnamed: C2.1, R5.2, U3.1
unnamed: C2.2, D2.1, R1.2, U2.3, U3.2
unnamed: C3.1, R7.1, R9.2, U1.7
unnamed: C3.2, R7.2, R8.1, U1.6
unnamed: C4.1, R10.2, U3.7
unnamed: C4.2, D4.1, R6.2, U2.10, U3.6
unnamed: D1.1, R4.1, U2.4
unnamed: D3.1, R9.1, U2.11
unnamed: D5.1, Q1.3
unnamed: D5.2, R11.2
unnamed: D6.2, U4.1
unnamed: D7.1, Q2.3
unnamed: D7.2, R18.2
unnamed: D8.2, U4.7
unnamed: D9.2, J7.+12V
unnamed: D11.1, J7.-12V
unnamed: J1.T, R3.2
unnamed: J2.T, R1.1, R5.1
unnamed: J3.T, R8.2
unnamed: J4.T, R6.1, R10.1
unnamed: J5.T, R13.2
unnamed: J6.T, R20.2
unnamed: Q1.1, R14.2
unnamed: Q2.1, R21.2
unnamed: R12.1, R24.1, U4.2, U4.6
unnamed: R13.1, R15.2, U4.3
unnamed: R20.1, R22.2, U4.5
VEE: C9.1, C10.1, D10.1, R16.1, R17.2, R23.1, U2.7

## KiCad design Modules/Slim Line/Slimline Clock Divider/Electronics/Main/Slimline Clock Divider SMD Main.kicad_pcb

File Modules/Slim Line/Slimline Clock Divider/README.md:

<h1>Slimline Clock Divider NG</h1>
<table>
	<tr valign="top">
		<td></td>
		<td>
			<p>
				Slimline Clock Divider NG
			</p>
		</td>
	</tr>
</table>

Parts:
C1, C4, C5, C6: 100nF; C_0402_1005Metric; MPN C1525
C2, C3: 10uF/16V; CP_EIA-3216-18_Kemet-A; MPN C7171
D1, D3: LED; LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm
D2, D4: 1N5819WS; D_SOD-323; MPN C191023
IC1: TL072CDT; SOIC-8_3.9x4.9mm_P1.27mm; MPN C6961
IC3: CD4069UBM96; SOIC-14_3.9x8.7mm_P1.27mm; MPN C93672
IC4: CD4024BM96; SOIC-14_3.9x8.7mm_P1.27mm; MPN C157535
J1: Clock; Jack_3.5mm_QingPu_WQP-PJ324M
J2: Out_Div_2; Jack_3.5mm_QingPu_WQP-PJ324M
J3: Out_Div_4; Jack_3.5mm_QingPu_WQP-PJ324M
J4: Reset; Jack_3.5mm_QingPu_WQP-PJ324M
J5: Out_Div_8; Jack_3.5mm_QingPu_WQP-PJ324M
J6: Out_Div_16; Jack_3.5mm_QingPu_WQP-PJ324M
J7: Power_2x5; Power_2x8_Horizontal
JP1: Inv_CLK; SolderJumper-3_P1.3mm_Bridged2Bar12_RoundedPad1.0x1.5mm
JP2: Inv_RST; SolderJumper-3_P1.3mm_Bridged2Bar12_RoundedPad1.0x1.5mm
Q1, Q2, Q3, Q4: MMBT3904; SOT-23; MPN C20526
R1, R2, R5: 100k; R_0402_1005Metric; MPN C25741
R4, R10, R15: 10k; R_0402_1005Metric; MPN C25744
R7, R14, R17, R19: 1k2; R_0603_1608Metric; MPN C22765
R8, R12, R13, R16, R18, R20: 1k; R_0603_1608Metric; MPN C21190

Connections:
+12V: C1.1, C2.1, C4.1, C5.1, D2.1 (K), IC1.8 (V+), IC3.14 (VCC), IC4.14 (VCC), Q1.3 (C), Q2.3 (C), Q3.3 (C), Q4.3 (C), R1.2
-12V: C3.2, C6.2, D4.2 (A), IC1.4 (V-)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.1, D1.1 (K), D3.1 (K), IC3.7 (GND), IC4.7 (GND), J1.S, J1.TN, J2.S, J3.S, J4.S, J4.TN, J5.S, J6.S, J7.GND, R2.1, R5.1, R8.2, R15.1, R16.2, R18.2, R20.2
unnamed: D1.2 (A), R12.2
unnamed: D2.2 (A), J7.+12V
unnamed: D3.2 (A), R13.2
unnamed: D4.1 (K), J7.-12V
unnamed: IC1.1, IC3.1, R12.1
unnamed: IC1.2 (-), IC1.6 (-), R1.1, R15.2
unnamed: IC1.3 (+), R2.2, R4.2
unnamed: IC1.5 (+), R5.2, R10.2
unnamed: IC1.7, IC3.5, R13.1
unnamed: IC3.2, IC3.3, JP1.1 (A)
unnamed: IC3.4, JP1.3 (B)
unnamed: IC3.6, IC3.9, JP2.3 (B)
unnamed: IC3.8, JP2.1 (A)
unnamed: IC4.1 (~CP), JP1.2 (C)
unnamed: IC4.2 (MR), JP2.2 (C)
unnamed: IC4.6 (Q3), Q4.1 (B)
unnamed: IC4.9 (Q2), Q3.1 (B)
unnamed: IC4.11 (Q1), Q2.1 (B)
unnamed: IC4.12 (Q0), Q1.1 (B)
unnamed: J1.T, R4.1
unnamed: J2.T, R7.2, R8.1
unnamed: J3.T, R14.2, R16.1
unnamed: J4.T, R10.1
unnamed: J5.T, R17.2, R18.1
unnamed: J6.T, R19.2, R20.1
unnamed: Q1.2 (E), R7.1
unnamed: Q2.2 (E), R14.1
unnamed: Q3.2 (E), R17.1
unnamed: Q4.2 (E), R19.1

Notices in the files:
README.md:
https://mirrors.creativecommons.org/presskit/buttons/88x31/svg/by-nc-sa.svg
